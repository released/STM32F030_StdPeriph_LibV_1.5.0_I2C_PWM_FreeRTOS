# Keil uVision project Project.uvprojx, settings and files
target STM32F030 (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,USE_DEFAULT_TIMEOUT_CALLBACK,
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc;..\..\..\Libraries\CMSIS\Include;..\..\..\Utilities\Third_Party\FreeRTOS\Source\include;..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\inc;..\..\..\Libraries\CMSIS\RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group CMSIS
    ../src/: system_stm32f0xx.c
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
  group StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dma.c stm32f0xx_flash.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_tim.c stm32f0xx_wwdg.c stm32f0xx_can.c stm32f0xx_crs.c stm32f0xx_exti.c stm32f0xx_iwdg.c stm32f0xx_rtc.c stm32f0xx_usart.c stm32f0xx_comp.c stm32f0xx_gpio.c stm32f0xx_syscfg.c stm32f0xx_dbgmcu.c stm32f0xx_pwr.c
  group User
    ../src/: App_Task.c Hw_config.c macro.c main.c stm32f0xx_it.c i2c_device.c Custom_ADC.c
  group FreeRTOS
    ../../../Utilities/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
